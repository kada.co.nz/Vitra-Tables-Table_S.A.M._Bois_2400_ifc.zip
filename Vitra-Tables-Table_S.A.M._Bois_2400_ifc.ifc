Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-06-02T16:38:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 02 16:38:29 2022 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\{DB207A00-AA87-4892-A832-86A2C7B37CC5}\ifc * Database version: 5507 * Database creation date: Thu Jun 02 16:38:29 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 02 16:38:29 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 02 16:38:29 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFurnishingElement: Table Solvay 2400, Vitra-Tables-Table_Solvay:Table Solvay 2400:32637
In: Level 1
Type - Material: Deep Black, Natural solid oak,oiled
Type - Constraints - table size: solvay 2400
Type - General - Author: BIMStone; BIMObjectName: Vitra-Tables-Table_Solvay; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Tables; NBSReference: 45-35-86/327; ProductInformation: Jean Prouvé developed Table Solvay during the Second World War and due to the scarcity of metal at that time, he designed the elegant piece with wooden legs. The solid wood components in a choice of natural oak, dark stained oak or American walnut lend the table a sense of ease and refinement.; Revision: n/a; Uniclass2: Pr_40_50_21_58; Uniclass2015Description: Occasional tables; Uniclass2015Reference: Pr_40_50_21_58; Version: 1; VersionDate: 02/06/2022
Type - Identity Data - Cost: 0; Description: Jean Prouvé developed Table Solvay during the Second World War and due to the scarcity of metal at that time, he designed the elegant piece with wooden legs. The solid wood components in a choice of natural oak, dark stained oak or American walnut lend the table a sense of ease and refinement.; Designer: Jean Prouvé; Manufacturer: Vitra; Model: Table Solvay 2400; OmniClass Number: 23.40.20.14.17.24; OmniClass Title: Coffee Tables; Type Name: Table Solvay 2400; URL: https://www.vitra.com/en-dk/living/product/details/table-solvay
Type - Materials and Finishes - Strut: Deep Black
Type - Other - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Tables; CodePerformance: n/a; Color: Wooden; Constituents: n/a; DurationUnit: Years; ExpectedLife: n/a; Family Name: Vitra-Tables-Table_Solvay; Features: n/a; Finish: Table top: 34 mm thick; solid wood in natural oak with oiled finish, dark stained oak with protective natural lacquer finish, or American walnut with oiled finish. Base: legs matched to table top, solid wood in natural oak with oiled finish, dark stained oak with protective natural lacquer finish, or American walnut with oiled finish; tubular steel crossbar with powder-coated finish (smooth). Origin of wood: oak (Quercus robur) from Western Europe and/or Poland; American walnut (Juglans nigra) from the USA.; Grade: n/a; Material: Wood; ModelNumber: 21203100; ModelReference: n/a; Name: Table_Solvay; ReplacementCost: n/a; Shape: Sculptured; Size: 2400x900x740 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Years; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 4.602 m2; Volume: 1.5984 m3
Materials and Finishes - Table tops/ legs: Natural solid oak,oiled
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Vitra-Tables-Table_Solvay: Table Solvay 2400; Family and Type: Vitra-Tables-Table_Solvay: Table Solvay 2400; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Tables-Table_Solvay: Table Solvay 2400; Type Id: Vitra-Tables-Table_Solvay: Table Solvay 2400; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
